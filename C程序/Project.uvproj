# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\App
  group User
    ./: STARTUP.A51
    ./User/: main.c public.c
  group App
    ./App/: I2C.c lcd1602.c
